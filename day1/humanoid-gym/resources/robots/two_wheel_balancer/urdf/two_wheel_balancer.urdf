Commit message: 课程学习

File: day1/humanoid-gym/resources/robots/two_wheel_balancer/urdf/two_wheel_balancer.urdf (robot description, URDF)
Before this commit: robot two_wheel_balancer, 3 links, 2 joints
Joints:
- joint wheel_L_joint: axis 0 1 0 -> 0 -1 0
